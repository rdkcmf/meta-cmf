SRC_URI_remove = "ftp://ftp.deepspace6.net/pub/ds6/sources/ipv6calc/ipv6calc-${PV}.tar.gz"
SRC_URI += "https://www.deepspace6.net/ftp/pub/ds6/sources/ipv6calc/ipv6calc-0.99.0.tar.gz"
