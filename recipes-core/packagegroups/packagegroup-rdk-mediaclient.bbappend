#RDEPENDS_packagegroup-rdk-generic-mediaclient += "virtual/wifi-hal"

RDEPENDS_packagegroup-rdk-generic-mediaclient_remove = "rdkbrowser"
RDEPENDS_packagegroup-rdk-generic-mediaclient_remove = "rdkbrowser-webserver"

RDEPENDS_packagegroup-rdk-generic-mediaclient_remove_ipclient = "tr69agent"
