require recipes-core/images/include/lxc-image.inc
require recipes-core/images/add-non-root-user-group.inc
