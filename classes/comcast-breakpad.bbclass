# Dummy function just to satisfy any component that inherits this class.
# This is only for build purposes.

PACKAGE_PREPROCESS_FUNCS += "breakpad_package_preprocess"
breakpad_package_preprocess () {
}
